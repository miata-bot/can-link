File: hardware/platform-i.mx6/nano.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Start reworking imx board into the new form factor
Other:
- removed sheet rp2040
